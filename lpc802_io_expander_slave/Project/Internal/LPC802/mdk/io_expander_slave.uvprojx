# Keil uVision project io_expander_slave.uvprojx, settings and files
target lpc8xx_io_expander_slave (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC824M201JHI33 NXP
  pack: NXP.LPC824_DFP.16.0.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lpc802_io_expander +hex
  AfterMake: $KARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x0)
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=3 oTime=1
  c define: LPC8XX
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\inc;..\..\..\..\Libraries\drivers_lpc800\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\utilities\structures
  asm define: RAM_TARGET
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x10000000 size 0x800
  group startup_lpc8xx
    ../../../../Libraries/startup/src/: system_LPC8xx.c
    ../../../../Libraries/startup/src/mdk/: startup_LPC8xx.s
  group user
    ../src/: main.c appdef.h
  group drivers_lpc800
    ../../../../Libraries/drivers_lpc800/src/: common.c gpio.c syscon.c uart.c i2c.c
  group utlitilies
    ../../../../Libraries/utilities/structures/: mq.c
