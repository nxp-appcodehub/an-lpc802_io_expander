# Keil uVision project lpc845_io_expander_master.uvprojx, settings and files
target flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC845M301JBD64 NXP
  pack: NXP.LPC845_DFP.14.0.0
  cpu: IRAM(0x10000000,0x00004000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: I2C_MasterSlave
  AfterMake: $KARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x0)
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Source_Code\peripherals_lib\inc; ..\..\Source_Code\utilities_lib\inc; ..\..\Source_Code\common\inc; ..\..\Source_Code\I2C_MasterSlave\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x4000
  group docs
    ../../Source_Code/I2C_MasterSlave/docs/: README.txt
  group inc
    ../../Source_Code/I2C_MasterSlave/inc/: chip_setup.h
  group src
    ../../Source_Code/common/src/: Keil_Retarget.c Keil_startup.s Serial.c system.c
    ../../Source_Code/I2C_MasterSlave/src/: I2C_MasterSlave_main.c
  group drivers
    ../../Source_Code/peripherals_lib/src/: gpio.c i2c.c swm.c syscon.c
    ../../Source_Code/utilities_lib/src/: utilities.c
